# Keil uVision project YM502_Test_Demo.uvprojx, settings and files
target CMS32M67xx (6210000::V6.21::ARMCLANG)
  device: CMS32M67xx48FA Cmsemicon
  pack: Cmsemicon.CMS32M67xx.0.1.6
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\CMSIS\Include;..\Device\Include;..\Driver\inc;..\..\..\..\Device\CMS32X506\Include;..\APP\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group MAIN
    ../MAIN/: main.c
  group App
    ../APP/Src/: retarget.c YM_ccp.c YM_dma.c YM_rgb.c YM_timer.c YM_uart.c YM_led.c YM_touch.c YM_epwm.c bsp_SysTick.c
  group Driver
    ../Driver/src/: dma.c delay.c gpio.c timer.c ccp.c uart.c cgc.c epwm.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
