# Keil uVision project iicaSendReceive.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32M67xx48FA Cmsemicon
  pack: Cmsemicon.CMS32M67xx.0.1.4
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\app\include;..\..\Driver\inc;..\..\Device\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./: main.c
  group App
    ./app/src/: iica_demo.c retarget.c delay_demo.c demo_uart.c
  group Bsp
    ../../Driver/src/: gpio.c uart.c cgc.c i2ca.c delay.c
    ./app/src/: isr.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
