# Keil uVision project ADC_HardwareTrigger.uvprojx, settings and files
target CMS32M67xx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32M67xx48FA Cmsemicon
  pack: Cmsemicon.CMS32M67xx.0.1.4
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\CMSIS\Include;..\..\..\Driver\inc;..\APP;..\..\..\..\Driver\inc;..\..\..\..\Device\CMS32X506\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ../: main.c
  group App
    ../APP/: retarget.c demo_adc.c isr.c demo_uart.c demo_epwm.c
  group Driver
    ../../../../Driver/src/: gpio.c uart.c cgc.c adc.c epwm.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
